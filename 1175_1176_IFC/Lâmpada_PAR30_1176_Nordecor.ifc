Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-11-07T10:45:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 07 10:45:56 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\a86d7717-4f3a-46cf-9080-d6bdeb4cc39d\80d7d934-960b-48b3-bfec-6069265354eb\ifc * Database version: 5507 * Database creation date: Fri Nov 07 10:45:55 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 07 10:45:56 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 07 10:45:56 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328354
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 1176, Lâmpada_PAR30_1175_1176_Nordecor_IFC:1176:328354
In: Nível 1
Type - Material: Metal - Ferro, Plástico - Branco - Fosco, Plástico - Acrilico - Translucido, LED
Type - Cotas - Altura: 119 mm; Diâmetro: 95 mm
Type - Dados - Data de atualização: 03/11/2025; Versão: 1
Type - Dados de identidade - Código Uniformat: D5020.20; Comentários de tipos: lâmpada LED PAR30, potência 28W, temperaturas 3000K ou 4000K, facho 24°, iluminação direcional, substituível, uso interno, eficiência luminosa alta; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Lâmpada de LED PAR30 28W 4000K 24º; Descrição UniFormat: Fontes de luz e lâmpadas; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Itajaí-SC / Brasil; Modelo: 1176; Nome do tipo: 1176; Nota-chave: 26 51 13; Número MasterFormat: 26 51 13; Número OmniClass: 23.80.70.00; Observação: Não dimerizável; Tipo de fixação: Soquete E27; Tipo de imagem: Imagem raster: 1175_1176.png; Tipo de luminária: Distribuição Direta / Facho Médio; Título MasterFormat: Lâmpadas de Diodo Emissor de Luz (LED); Título OmniClass: Lighting; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/lampada-led-sof-par30-cdmr-24-28w-3-000k-4-000k-irc95/; Vida útil: 25.000h
Type - Elétrico - Comentários de voltagem: 100-240VAC; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Lâmpada: 0 W
Type - Engenharia elétrica - Corrente elétrica: 0 A; Fator de potência - Lâmpada: 0.92; Frequência: 50 Hz; Voltagem - Lâmpada: 0 V
Type - Estrutural - Peso da luminária: 0
Type - Fotométricos - Ângulo de abertura: 24 deg; Fluxo luminoso: 2500 lm; IRC: 95; Potência: 28 W; Temperatura da cor: 4000 K
Type - Materiais e acabamentos - PAR30: Alumínio e polímero sintético
Type - Outros - Categoria: Luminárias; 3000K - 24º: no; 4000K - 24º: yes; Branco: yes; Nome da família: Lâmpada_PAR30_1175_1176_Nordecor_IFC
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 1176; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.022492 m2; Volume: 0.000310501 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Lâmpada_PAR30_1175_1176_Nordecor_IFC: 1176; Família e tipo: Lâmpada_PAR30_1175_1176_Nordecor_IFC: 1176; ID de tipo: Lâmpada_PAR30_1175_1176_Nordecor_IFC: 1176; Tipo: Lâmpada_PAR30_1175_1176_Nordecor_IFC: 1176
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
